# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ch
  c flags: Optim=1 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\..\os\kernel\include;..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\common\ARMCMx\CMSIS\include;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F4xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32\GPIOv2;..\..\..\os\hal\platforms\STM32F4xx;..\..\..\os\various;..\..\..\boards\ST_STM32F4_DISCOVERY;..\..\..\test;..\..\..\Quad\MPU6050\Examples\MPU6050_DMP6;..\..\..\Quad\MPU6050;..\..\..\Quad\I2Cdev;..\..\..\Quad\Regelung;..\..\..\Quad\Regelung;..\..\..\Quad\;..\..\..\ext\fatfs-0.8b-patched\fatfs\src;..\..\..\Quad\mavlink\carrera_mavlink;..\..\..\Quad\mavlink;..\..\..\Quad\Flash_driver;..\..\..\Quad\FreeIMU;..\..\..\Quad\MS561101BA;..\..\..\Quad\HMC58X3;..\..\..\Quad\MPU60X0
  asm misc: --cpreproc
  asm include: ..\;..\..\..\boards\ST_STM32F4_DISCOVERY;..\..\..\os\ports\RVCT\ARMCMx\STM32F4xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group board
    ../../../boards/ST_STM32F4_DISCOVERY/: board.c
  group port
    ../../../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c
    ../../../os/ports/RVCT/ARMCMx/STM32F4xx/: vectors.s
    ../../../os/ports/common/ARMCMx/: nvic.c
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group hal
    ../../../os/hal/src/: adc.c hal.c pal.c pwm.c serial.c spi.c i2c.c ext.c mmc_spi.c tm.c gpt.c
    ../../../os/hal/platforms/STM32/: ext_lld.c
  group platform
    ../../../os/hal/platforms/STM32F4xx/: adc_lld.c hal_lld.c stm32_dma.c gpt_lld.c
    ../../../os/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ../../../os/hal/platforms/STM32/: pwm_lld.c serial_lld.c spi_lld.c i2c_lld.c
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
  group demo
    ../: main.cpp
  group various
    ../../../os/various/: chprintf.c
  group Quad
    ../../../Quad/: Racecontrol.cpp ExternalInterrupt.cpp GCS.cpp
    ../../../Quad/Flash_driver/: stm32f4xx_flash.cpp Flash.cpp eeprom.cpp
